FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-modbus_reply-validate-FC22-request-length-before-writing-register.patch"
