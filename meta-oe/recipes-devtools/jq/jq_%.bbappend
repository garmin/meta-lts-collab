FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://CVE-2026-32316.patch \
    file://CVE-2026-33947.patch \
    file://CVE-2026-33948.patch \
    file://CVE-2026-39979.patch \
    "
