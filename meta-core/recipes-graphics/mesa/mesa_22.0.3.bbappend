FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://CVE-2026-40393-01.patch \
    file://CVE-2026-40393-02.patch \
    file://CVE-2026-40393-03.patch \
    file://CVE-2026-40393-04.patch \
    "
