# not-applicable-config: stress-test is an uninstalled test
CVE_CHECK_WHITELIST += "CVE-2023-37769"
