INSANE_SKIP:${PN}-ptest:append = " dev-deps"

RDEPENDS_${PN}-ptest += "${PN}-dev"
