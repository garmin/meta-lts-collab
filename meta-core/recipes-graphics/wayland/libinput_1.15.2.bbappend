# cpe-incorrect:
# The lua plugin was not even added until 1.29.901~96, therefore this CVE does
# not apply to our version and we can safely ignore it.
CVE_CHECK_WHITELIST += "CVE-2026-35093"
