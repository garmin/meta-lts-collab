FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "\
    file://CVE-2026-34933-1.patch \
    file://CVE-2026-34933-2.patch \
    "

