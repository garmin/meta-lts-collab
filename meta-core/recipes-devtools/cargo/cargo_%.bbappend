CVE_PRODUCT = "rust-lang:cargo"
