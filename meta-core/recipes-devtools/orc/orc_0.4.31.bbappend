# distinguish from apache:orc
CVE_PRODUCT = "gstreamer:orc"
