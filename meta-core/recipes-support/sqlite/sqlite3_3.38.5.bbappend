FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

SRC_URI += "\
    file://CVE-2026-11822_CVE-2026-11824.patch \
"
