FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "\
    file://CVE-2026-35328.patch \
"
